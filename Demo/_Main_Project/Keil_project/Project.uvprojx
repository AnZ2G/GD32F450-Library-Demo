# Keil uVision project Project.uvprojx, settings and files
target GD32F4XX (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F450ZI GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F450
  c include: ..\..\_Main_Project;..\..\Libraries\Firmware\CMSIS;..\..\Libraries\Firmware\CMSIS\GD\GD32F4xx\Include;..\..\Libraries\Firmware\CMSIS\GD\GD32F4xx\Source\ARM;..\..\Libraries\Firmware\GD32F4xx_standard_peripheral\Include;..\..\Libraries\Utilities;..\..\Libraries\Utilities\Third_Party\wh;..\..\Libraries\Utilities\Third_Party\GD32F450_Main_Board_Camera_V1.0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../: main.c systick.c gd32f4xx_it.c Track.c Image.c
  group CMSIS
    ../../Libraries/Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Startup
    ../../Libraries/Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450.s
  group Doc
    ../: readme.txt
  group Peripherals
    ../../Libraries/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Utilities
    ../../Libraries/Utilities/: gd32f450_board.c
    ../../Libraries/Utilities/Third_Party/wh/: wh_adc.c wh_exti.c wh_flash.c wh_gpio.c wh_pit.c wh_pwm.c wh_spi.c wh_systick.c wh_tim.c wh_uart.c wh_i2c.c
  group GD32F450_MainBoard_V1.0
    ../../Libraries/Utilities/Third_Party/GD32F450_Main_Board_Camera_V1.0/: Encoder.c HCI.c KEY.c LED.c oled.c pwm.c SEEKFREE_MT9V03X.c TFT.c UART.c zf_camera.c motor.c Camera.c
software components: CMSIS:CORE 5.4.0
